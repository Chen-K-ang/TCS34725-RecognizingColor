# Keil uVision project program.uvprojx, settings and files
target STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: program +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\lib\inc;.\startup;.\system\usart;.\system\sys;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Lib
    ./lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
    ../../技术资料/TCS34725方形—双孔资料包/TCS3472X DEMO例程（ Arduino stm32 ）/Tcs3472x_DEMO/STM32_tcs3472x/lib/src/: stm32f10x_flash.c
  group Sys
    ./system/sys/: sys.c
    ./system/usart/: usart.c
  group User
    ./user/: main.c
